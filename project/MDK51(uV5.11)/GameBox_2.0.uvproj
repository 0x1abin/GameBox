# Keil uVision project GameBox_2.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: GameBox_2.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\source;..\..\source\HAL
  group USER
    ./: STARTUP.A51
    ../../source/: main.c
  group HAL
    ../../source/HAL/: display.c keypad.c
